# Keil uVision project second_attempt.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: second_attempt
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: main.c systick.c
  group New Group
    ./: systick.h
software components: CMSIS:CORE 5.6.0, Device:GD32F30x_StdPeripherals:GPIO 2.2.0, Device:GD32F30x_StdPeripherals:MISC 2.2.0, Device:GD32F30x_StdPeripherals:PMU 2.2.0, Device:GD32F30x_StdPeripherals:RCU 2.2.0, Device:GD32F30x_StdPeripherals:RTC 2.2.0, Device:GD32F30x_StdPeripherals:TIMER 2.2.0, Device:GD32F30x_StdPeripherals:USART 2.1.0, Device:GD32F30x_libopt 2.2.0, Device:Startup 2.2.0
