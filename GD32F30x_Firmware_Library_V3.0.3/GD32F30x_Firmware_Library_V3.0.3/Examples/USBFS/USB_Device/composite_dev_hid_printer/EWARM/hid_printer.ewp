# IAR project hid_printer.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F307xC GD GD32F307xC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32F30X_CL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Firmware\CMSIS\GD\GD32F30x\Include; ..\..\..\..\..\Firmware\GD32F30x_standard_peripheral\Include; ..\..\..\..\..\Utilities; ..\..\..\..\..\Firmware\GD32F30x_usbfs_library\device\class\hid\Include; ..\..\..\..\..\Firmware\GD32F30x_usbfs_library\device\class\printer\Include; ..\..\..\..\..\Firmware\GD32F30x_usbfs_library\device\core\Include; ..\..\..\..\..\Firmware\GD32F30x_usbfs_library\driver\Include; ..\..\..\..\..\Firmware\GD32F30x_usbfs_library\ustd\class\hid; ..\..\..\..\..\Firmware\GD32F30x_usbfs_library\ustd\common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CDC_ACM.srec
  ILINK.IlinkOutputFile: hid_printer.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: app.c custom_hid_itf.c gd32f30x_hw.c gd32f30x_it.c hid_printer_wrapper.c
  group CMSIS
    ../src/: system_gd32f30x.c
  group Doc
    ../: readme.txt
  group GD32F30x_EVAL
    ../../../../../Utilities/: gd32f307c_eval.c
  group GD32F30x_StdPeriph
    ../../../../../Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_ctc.c gd32f30x_exti.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_timer.c gd32f30x_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F30x/Source/IAR/: startup_gd32f30x_cl.s
  group USB_Class
    ../../../../../Firmware/GD32F30x_usbfs_library/device/class/hid/Source/: custom_hid_core.c
    ../../../../../Firmware/GD32F30x_usbfs_library/device/class/printer/Source/: printer_core.c
  group USB_Device
    ../../../../../Firmware/GD32F30x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Drivers
    ../../../../../Firmware/GD32F30x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
