# IAR project usbh_hid.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F307xC GD GD32F307xC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32F30X_CL; USE_LCD
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Firmware\CMSIS\GD\GD32F30x\Include; ..\..\..\..\..\Firmware\GD32F30x_standard_peripheral\Include; ..\..\..\..\..\Utilities\LCD_Commom; ..\..\..\..\..\Utilities; ..\..\..\..\..\Firmware\GD32F30x_usbfs_library\driver\Include; ..\..\..\..\..\Firmware\GD32F30x_usbfs_library\host\class\hid\Include; ..\..\..\..\..\Firmware\GD32F30x_usbfs_library\host\core\Include; ..\..\..\..\..\Firmware\GD32F30x_usbfs_library\ustd\common; ..\..\..\..\..\Firmware\GD32F30x_usbfs_library\ustd\class\hid
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_HID.srec
  ILINK.IlinkOutputFile: usbh_hid.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: gd32f30x_it.c gd32f30x_usb_hw.c main.c usbh_usr.c usbh_usr_lcd.c
  group CMSIS
    ../src/: system_gd32f30x.c
  group Doc
    ../: readme.txt
  group GD32F30x_EVAL
    ../src/: gd32f307c_eval.c lcd_log.c
    ../../../../../Utilities/: gd32f307c_lcd_eval.c
    ../../../../../Utilities/LCD_Commom/: lcd_font.c
  group GD32F30x_Peripherals
    ../../../../../Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_timer.c gd32f30x_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F30x/Source/IAR/: startup_gd32f30x_cl.s
  group USB_Class
    ../../../../../Firmware/GD32F30x_usbfs_library/host/class/hid/Source/: usbh_hid_core.c usbh_standard_hid.c
  group USB_Drivers
    ../../../../../Firmware/GD32F30x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../Firmware/GD32F30x_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
